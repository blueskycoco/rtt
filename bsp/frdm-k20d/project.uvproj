# Keil uVision project project.uvproj, settings and files
target RT-Thread (ARM-ADS)
  device: MK20DX256xxx7 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: rt-thread-k20d +hex
  AfterMake: fromelf.exe --bin -o .\build\rtthread.bin .\build\rt-thread-k20d.axf
  c flags: Optim=2
  c include: applications;.;board;device;device\MK20DX256VLL\inc;..\..\include;..\..\libcpu\arm\cortex-m4;..\..\libcpu\arm\common;..\..\components\dfs;..\..\components\dfs\include;..\..\components\dfs\filesystems\romfs;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\rtgui\components\rtgui\include;..\..\components\rtgui\components\rtgui\include;..\..\components\rtgui\components\rtgui\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c startup.c
  group Board
    board/: board.c drv_uart.c ili9341.c led.c
  group Device
    device/: system_MK20D7.c
    device/MK20DX256VLL/drivers/: flexbus.c port.c
    device/TOOLCHAIN_ARM_STD/: startup_MK20D7.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group RTGUI
    ../../components/rtgui/components/rtgui/common/: animation.c animation_engines.c asc12font.c asc16font.c blit.c color.c dc.c dc_blend.c dc_buffer.c dc_client.c dc_hw.c dc_rotozoom.c dc_trans.c filerw.c font.c font_bmp.c font_fnt.c font_freetype.c font_hz_bmp.c font_hz_file.c framebuffer_driver.c hz12font.c hz16font.c image.c image_container.c image_hdc.c image_xpm.c matrix.c pixel_driver.c region.c rtgui_app.c rtgui_mv_model.c rtgui_object.c rtgui_system.c rtgui_theme.c rtgui_xml.c
    ../../components/rtgui/components/rtgui/server/: driver.c gesture.c mouse.c server.c topwin.c touch.c
    ../../components/rtgui/components/rtgui/widgets/: box.c button.c caret.c checkbox.c combobox.c container.c digfont.c digtube.c edit.c filelist_view.c groupbox.c iconbox.c label.c list_view.c listbox.c listctrl.c menu.c mv_view.c notebook.c panel.c plot.c plot_curve.c progressbar.c radiobox.c scrollbar.c slider.c staticline.c text_encoding.c textbox.c textview.c title.c widget.c window.c
